# IAR project Backup of Acopter.ewp, settings and files
configuration Acopter (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Src\poliot; ../Src; ../Src\SYSTEM; ../Src\SYSTEM\delay; ../Src\SYSTEM\sys; ../Src\UCOSII\CONFIG; ../Src\UCOSII\CORE; ../Src\UCOSII\PORT; ../Src\math; ../Src\math\matrix
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Acopter.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/acopter_driver
    ../Src/: AHRS.cpp AHRS.h baro.cpp baro.h datatrans.cpp datatrans.h flash.cpp flash.h gps.cpp gps.h i2c_soft.cpp i2c_soft.h led.cpp led.h magnet.cpp magnet.h pwm.cpp pwm.h rc.cpp rc.h sonar.cpp sonar.h
  group Application/User/main
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/math
    ../Src/math/: filter.cpp filter.h matrix3.cpp matrix3.h quaternion.cpp quaternion.h rotation.h vector3.cpp vector3.h
    ../Src/: mymath.cpp mymath.h
  group Application/User/math/kalman
    ../Src/math/: kalman.cpp kalman.h
  group Application/User/math/matrix
    ../Src/math/matrix/: Matrix.hpp
  group Application/User/poliot
    ../Src/poliot/: ctrl.cpp ctrl.h height_ctrl.cpp height_ctrl.h imu.cpp imu.h parameter.cpp parameter.h
  group Application/User/task
    ../Src/: include.h init.cpp init.h scheduler.cpp scheduler.h time.cpp time.h
  group Application/User/ucos/system
    ../Src/SYSTEM/delay/: delay.c
    ../Src/SYSTEM/: misc.c
  group Application/User/ucos/ucos_config
    ../Src/UCOSII/CONFIG/: includes.h os_cfg.h
  group Application/User/ucos/ucos_core
    ../Src/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Application/User/ucos/ucos_port
    ../Src/UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
